## firmware/pod/boards/silverajat/liftpod_v2/board.yml
```yaml
board:
  name: liftpod_v2
  full_name: Lift pod v2
  vendor: silverajat
  socs:
  - name: nrf52840
```
